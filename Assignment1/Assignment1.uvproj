# Keil uVision project Assignment1.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: Assignment1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  group Source Group 1
    ./: add32b_num.s add16_halfword.s factorial.s array_5_32b_num.s ones_zeroes_32b_num.s hexa2ascii.s factorial_subroutine.s check_positive_number.s sqrroot_num.s string_length.s
